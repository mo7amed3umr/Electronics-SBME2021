TABLE EQU 100H
ORG 0
MAIN:MOV DPTR,#TABLE
MOV B,#10
MOV A,#30
DIV AB
MOV R4,A
MOV R5,B
LOOP1:MOVC A,@A+DPTR
	  MOV P1,A
	  MOV A,R5
	  LOOP2:MOVC A,@A+DPTR
	  MOV P2,A
      CJNE R5,#0,DECRIMENT
      ACALL TOGGLE
      DEC R4
      MOV A,R4
      ACALL DELAY 
      CJNE R4,#0,LOOP1
      JMP MAIN	  
DECRIMENT:DEC R5
MOV B,R5
ACALL DELAY
LJMP LOOP2
 
ORG TABLE
DB 3FH,06H,5BH,4FH,66H,6DH,7DH,07H,7FH,6FH 
DELAY: MOV R2, #8
HERE2: MOV R1, #0
HERE1: MOV R0, #0
HERE: DJNZ R0, HERE
	  DJNZ R1, HERE1 
	  DJNZ R2, HERE2 
	  RET
TOGGLE:MOV R5,#9
MOV A,R5
ACALL DELAY
RET 



END